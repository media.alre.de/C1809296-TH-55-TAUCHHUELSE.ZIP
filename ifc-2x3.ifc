Properties of the parts of a building model (IFC2X3)

# File
Description: Tauchhülse, 55 mm, Ms vernickelt, Durchmesser InnenxAußen 8 x 10 mm, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: C1809296, Tauchhülse, 55 mm, Ms vernickelt, Durchmesser InnenxAußen 8 x 10 mm
In: Raum
Description: Tauchhülse, 55 mm, Ms vernickelt, Durchmesser Innen x Außen 8 x 10 mm. Für Fühler mit Durchmesser 7,7 mm, Kapillarthermostate JET / JMT / WR 81.; Classification: EC010502 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: C1809296; ModelLabel: TH-55; GlobalTradeItemNumber: 4050528018267; ProductURL: https://alre.de/produkt_C1809296
Pset_Specification - NominalLength: 0.073 m; NominalWidth: 0.022 m; NominalDepth: 0.022 m; NetWeight: 0.087
Pset_ALRE_ETIM_Properties - Außendurchmesser: 10; Innendurchmesser: 8; Druckstufe Artikel: PN 20; Material Tauchrohr: Messing; Einstecklänge: 55; Nenndurchmesser Anschluss: 1/2 Zoll (15); ETIM-Klasse: EC010502; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-C1809296.pdf
